Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: 29f8c4bb-a7dd-4f7b-a3c5-a8c80e09253a.ifc
Time: 2022-04-14T14:57:15
Author: BouwConnect Bibliotheek
Organization: De Twee Snoeken
Written by: IFC Engine DLL
Made in: BouwConnect Bibliotheek
Authorization: De Twee Snoeken

# IfcSite, Kavel
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Bouwlaag
In: Gebouw
Elevation: 0 mm

# IfcBuildingElementProxy
In: Bouwlaag
Material: terracotta
Pset_Data - WUID: AgAAAAQmWAABAAAAAvMAAAVWkAAAjxUAAPbGAADupAAAFL8AAAAA; Hyperlink: https://bcb-online.nl/s/01082d49885084a989eda9563f4df8186; serie: Vlakke Muldenpan D-13-U; soortelijke warmte: 840 j/kg·k; KOMO productcertificaat: True; NL-SfB tabel 3: g9; vorstbestendig: True; merk: Nelskamp; KOMO attest: True; STABU2: 33.41.10; lengte: 439 mm; eenheid: st
